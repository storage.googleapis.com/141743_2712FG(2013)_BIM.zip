Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-20T10:55:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 20 10:55:59 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{D1DDECA6-156F-4F2A-B64F-E80631F46F5D}\ifc * Database version: 5507 * Database creation date: Wed Jun 20 10:55:58 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 20 10:55:59 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 20 10:55:59 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 2712FG Washbasin faucet, 2712FG(2013):2712FG Washbasin faucet:327089
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 145 mm; FaucetNominalHeight: 163 mm; FaucetNominalWidth: 54 mm; HandShowerNominalDepth: 68.5 mm; HandShowerNominalHeight: 317.5 mm; HandShowerNominalWidth: 57 mm; InletConnectionSize: 10 mm
Type - General - Author: Convergo AB; BIMObjectName: 2712FG(2013); ConvergoRefNr: 0087-1806-0090-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for washbasins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 14/06/2018
Type - Green Building Properties - EAN Number: 6414150073137; EN Standard: EN 817; LVI Number: 6110148; Noise Class: I (ISO 3822); NRF Number: 4200111; RSK Number: 8348031; STF Certificate: VTT-RTH-00007-14; VVS Number: 703885534
Type - Identity Data - Class: Single lever; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 2712FG Washbasin faucet; Name_en: 2712FG Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2712FG; Product Datasheet: https://www.oras.com/datasheet/2712FG/en; Product Family: Oras Optima; Product URL: https://www.oras.com/en/products/oras-optima/product/2712FG/; Type Name: 2712FG Washbasin faucet
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: ECO button, lead free; Aerator: Aerator; Eco Flow At 300kPa: 0.00282517 m3/s; Flow: Limitation option for maximum flowrate; Flow Rate At 300kPa: 0.00423776 m3/s; Hand Shower: Bidetta handshower; Installation Type: Deck mounted; Lever Handle: Easy grip lever; Max. Hot Water Supply: 80 kg/K/s3; Pipes: Flexible inlet pipes; Pressure Loss With Flow 01ls: 200000 Pa; Shower Parts: Handshower bracket, showerhose; Spout Type: Fixed spout
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2712FG(2013); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2712FG; Name: 2712FG Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:54x145x163 mm / Hand shower: 57x69x318 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text - Health Sales Arguments: Lead free
Pset_ManufacturerTypeInformation - ModelReference: 2712FG; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2712FG Washbasin faucet
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.0851173 m2; Volume: 0.00252068 m3
Identity Data - Mark: 15
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2712FG(2013): 2712FG Washbasin faucet; Family and Type: 2712FG(2013): 2712FG Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2712FG(2013): 2712FG Washbasin faucet; Type Id: 2712FG(2013): 2712FG Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
